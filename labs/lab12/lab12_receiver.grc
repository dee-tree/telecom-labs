options:
  parameters:
    author: Dmitriy Sokolov (Barry Duggan)
    generate_options: qt_gui
    id: lab12_receiver
    output_language: python
    title: SSB_rcv_test
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: bfo
  id: variable_qtgui_range
  parameters:
    label: Fine tuning
    rangeType: int
    start: '0'
    step: '10'
    stop: '3000'
    value: '1500'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: '53000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: (int)(samp_rate/audio_rate)
  states: {}
- name: reverse
  id: variable_qtgui_chooser
  parameters:
    label: Sideband
    label0: Upper
    label1: Lower
    num_opts: '2'
    option0: '-1'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Tuning
    rangeType: int
    start: '48000'
    step: '100'
    stop: '58000'
    value: '51500'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1.0'
    value: '0.2'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1500'
    offset: '0'
    phase: '0'
    samp_rate: '32000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1500'
    offset: '0'
    phase: '0'
    samp_rate: '32000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: W:\edu\telecom-labs\labs\lab12\ssb_lsb_256k_complex2.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: USB/LSB
    const: reverse
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tuning
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,3000,100)
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
